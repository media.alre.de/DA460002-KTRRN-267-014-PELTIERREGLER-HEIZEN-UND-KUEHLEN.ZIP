Properties of the parts of a building model (IFC4)

# File
Description: Schaltschrankthermostat elektronisch für Peltiermodule – Heizen und Kühlen. 24 VDC, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: DA460002, Schaltschrankthermostat elektronisch für Peltiermodule – Heizen und Kühlen. 24 VDC
In: Raum
Description: Dieser Regler für die Ansteuerung von Peltiermodulen mit Lüfter zur Klimatisierung von Schaltschränken. Der KTRRN verfügt über zwei Regelbereiche für die Funktionen Heizen und Kühlen. Im unteren Einstellbereich wird der Schaltpunkt für Heizen, im oberen Einstellbereich der Schaltpunkt für Kühlen gewählt. Die Einstellbereiche sind durch einen Bereich von 10 K getrennt.; Classification: EC004587 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: DA460002; ModelLabel: KTRRN-267.014; GlobalTradeItemNumber: 4050528028297; ProductURL: https://alre.de/produkt_DA460002
Pset_Specification - NominalLength: 0.086 m; NominalWidth: 0.059 m; NominalDepth: 0.036 m; NetWeight: 0.104
Pset_ALRE_ETIM_Properties - Montageart: Klemmbefestigung; Ausführung: Thermostat; Ausführung der Schaltfunktion: Wechsler (NO/NC); Bemessungsspannung DC: 24; Bemessungsstrom In: 16; Einstellbereich Temperatur: 0; ETIM-Klasse: EC004587; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-DA460002.pdf
